# Keil uVision project eth_to_serial_twrk60n512.uvprojx, settings and files
target int flash debug (5060020::V5.06 (build 20)::ARMCC)
  device: MK60DN512xxx10 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4")
  output: eth_to_serial.axf +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: -J../../.. 
-J../../../../../../lib/twrk60n512.uv4/debug/bsp/Generated_Code 
-J../../../../../../lib/twrk60n512.uv4/debug 
-J../../../../../../lib/twrk60n512.uv4/debug/bsp 
-J../../../../../../lib/twrk60n512.uv4/debug/psp 
-J../../../../../../lib/twrk60n512.uv4/debug/rtcs 
 
-J#J --library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../..;../../../../../../lib/twrk60n512.uv4/debug/bsp/Generated_Code;../../../../../../lib/twrk60n512.uv4/debug;../../../../../../lib/twrk60n512.uv4/debug/bsp;../../../../../../lib/twrk60n512.uv4/debug/psp;../../../../../../lib/twrk60n512.uv4/debug/rtcs;..\..\..\..\..\..\lib\twrk60n512.uv4\debug\shell;..\..\..\MQTTPacket\src;..\..\..\MQX
  asm misc: --cpreproc_opts '-D_DEBUG=1' --cpreproc
  asm include: ../../../../../../lib/twrk60n512.uv4/debug/bsp/Generated_Code;../../../../../../lib/twrk60n512.uv4/debug;../../../../../../lib/twrk60n512.uv4/debug/bsp;../../../../../../lib/twrk60n512.uv4/debug/psp;../../../../../../lib/twrk60n512.uv4/debug/rtcs
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../lib/twrk60n512.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../lib/twrk60n512.uv4/debug/bsp/bsp.lib 
../../../../../../lib/twrk60n512.uv4/debug/psp/psp.lib 
../../../../../../lib/twrk60n512.uv4/debug/rtcs/rtcs.lib 
../../../../../../lib/twrk60n512.uv4/debug/shell/shell.lib 
../../../../../../lib/twrk60n512.uv4/debug/bsp/bsp.lib(vectors.o) 
../../../../../../lib/twrk60n512.uv4/debug/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
  group Sources
    ../../../: demo.c config.h dsdriver_ver_a.c dsdriver_vera.h
  group MQTTPACKET
    ../../../MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
target int flash release (5060020::V5.06 (build 20)::ARMCC)
  device: MK60DN512xxx10 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4")
  output: eth_to_serial.axf +hex
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG=1
  c misc: -J../../.. 
-J../../../../../../lib/twrk60n512.uv4/release/bsp/Generated_Code 
-J../../../../../../lib/twrk60n512.uv4/release 
-J../../../../../../lib/twrk60n512.uv4/release/bsp 
-J../../../../../../lib/twrk60n512.uv4/release/psp 
-J../../../../../../lib/twrk60n512.uv4/release/rtcs 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../..;../../../../../../lib/twrk60n512.uv4/release/bsp/Generated_Code;../../../../../../lib/twrk60n512.uv4/release;../../../../../../lib/twrk60n512.uv4/release/bsp;../../../../../../lib/twrk60n512.uv4/release/psp;../../../../../../lib/twrk60n512.uv4/release/rtcs
  asm misc: --cpreproc_opts '-DNDEBUG=1' --cpreproc
  asm include: ../../../../../../lib/twrk60n512.uv4/release/bsp/Generated_Code;../../../../../../lib/twrk60n512.uv4/release;../../../../../../lib/twrk60n512.uv4/release/bsp;../../../../../../lib/twrk60n512.uv4/release/psp;../../../../../../lib/twrk60n512.uv4/release/rtcs
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../lib/twrk60n512.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../lib/twrk60n512.uv4/release/bsp/bsp.lib 
../../../../../../lib/twrk60n512.uv4/release/psp/psp.lib 
../../../../../../lib/twrk60n512.uv4/release/rtcs/rtcs.lib 
../../../../../../lib/twrk60n512.uv4/release/bsp/bsp.lib(vectors.o) 
../../../../../../lib/twrk60n512.uv4/release/psp/psp.lib(linker_symbols.o) 
--keep linker_symbols.o(KERNEL_DATA_START) 
--keep linker_symbols.o(KERNEL_DATA_END) 
--keep linker_symbols.o(BOOT_STACK) 
--keep vectors.o(.vectors_rom) 
--remove 
--autoat 
--entry 
__boot
